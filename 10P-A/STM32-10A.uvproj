# Keil uVision project STM32-10A.uvproj, settings and files
target 10P-A (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-10P +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;.\BSP;.\User;..\10P-A
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Readme
    ./: readme.txt
  group BSP
    ./BSP/: stm32_ub_led.c Tsystick.c stm32_ub_adc.c stm32_ub_cd4051.c stm32_ub_dma_usart1.c stm32_ub_relay.c
  group User
    ./User/: main.c task.c stm32f10x_it.c input_process.c adc_filter.c queue_process.c
