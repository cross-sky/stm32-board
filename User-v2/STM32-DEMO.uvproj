# Keil uVision project STM32-DEMO.uvproj, settings and files
target 10P-A (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-10P +hex
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group 10P-A
    ./: main.c stm32_ub_led.c stm32f10x_it.c task.c Tsystick.c stm32_ub_button.c stm32_ub_eeprom.c stm32_ub_iic.c stm32_ub_pcf8563.c stm32_ub_lcd.c stm32_ub_menu.c stm32_ub_params.c stm32_ub_offstatus.c stm32_ub_dma_usart1.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Readme
    ../: readme.txt
